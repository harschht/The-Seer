options:
  parameters:
    author: Tate Harsch-Hudspeth & Evan Peelen, Tested by Victor Madrid
    description: This flowgraph runs the power only Rx 3 antenna array for The Seer
    generate_options: qt_gui
    id: the_seer_rx_flow_3P
    output_language: python
    title: 'Rx Antenna Array - 3AA - Only Power: The Seer'
  states: {}

blocks:
- name: fft_bins
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '750000000'
  states: {}
- name: head
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: k
  id: variable
  parameters:
    comment: |-
      k = -10*log10(samp_rate)
      Variable "k" must be manually changed if 
      samp_rate is changed.
    value: '-60.103'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: skip_bins
  id: variable
  parameters:
    value: int(fft_bins/2+fft_bins/samp_rate)+1
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_bins
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_bins
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_bins
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: A1_mag_M1.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: A2_mag_M1.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: A3_mag_M1.dat
    type: float
  states: {state: disabled}
- name: blocks_head_1_0_0
  id: blocks_head
  parameters:
    num_items: head
    type: float
  states: {}
- name: blocks_head_1_0_0_1
  id: blocks_head
  parameters:
    num_items: head
    type: float
  states: {}
- name: blocks_head_2_0
  id: blocks_head
  parameters:
    num_items: head
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_2_0_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1024'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_2_0_0_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1024'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_2_0_0_0_0_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1024'
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_moving_average_xx_2_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: k
    n: '10'
    vlen: fft_bins
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: k
    n: '10'
    vlen: fft_bins
  states: {}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: k
    n: '10'
    vlen: fft_bins
  states: {}
- name: blocks_skiphead_0_1_0_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip_bins
    type: float
  states: {}
- name: blocks_skiphead_0_1_0_0_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip_bins
    type: float
  states: {}
- name: blocks_skiphead_0_1_0_0_0_0_0_0_0
  id: blocks_skiphead
  parameters:
    num_items: skip_bins
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1_1_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_bins
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1_1_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_bins
    type: float
  states: {}
- name: blocks_vector_to_stream_0_1_1_0_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_bins
    type: float
  states: {}
- name: fft_vxx_0_1_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_1_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_1_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: A0
    ant1: A1
    ant2: A2
    bb_gain0: '20'
    bb_gain1: '20'
    bb_gain2: '20'
    corr1: '0'
    corr2: '0'
    dc_offset_mode1: '0'
    dc_offset_mode2: '0'
    freq0: freq
    freq1: 750e6
    freq2: 750e6
    gain0: '40'
    gain1: '40'
    gain2: '40'
    gain_mode0: 'False'
    gain_mode1: 'False'
    gain_mode2: 'False'
    if_gain0: '20'
    if_gain1: '20'
    if_gain2: '20'
    iq_balance_mode1: '0'
    iq_balance_mode2: '0'
    nchan: '3'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,2,1,1
    max: '10'
    min: '0'
    name: '"Pr_1"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,2,1,1
    max: '10'
    min: '0'
    name: '"Pr_2"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,2,1,1
    max: '10'
    min: '0'
    name: '"Pr_3"'
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_0_0_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_head_1_0_0, '0', blocks_moving_average_xx_1_0_0, '0']
- [blocks_head_1_0_0_1, '0', blocks_moving_average_xx_1_0_0_1, '0']
- [blocks_head_2_0, '0', blocks_moving_average_xx_2_0, '0']
- [blocks_keep_one_in_n_0_2_0_0_0_0_0, '0', blocks_head_1_0_0, '0']
- [blocks_keep_one_in_n_0_2_0_0_0_0_0_0, '0', blocks_head_1_0_0_1, '0']
- [blocks_keep_one_in_n_0_2_0_0_0_0_0_0_0, '0', blocks_head_2_0, '0']
- [blocks_moving_average_xx_1_0_0, '0', blocks_file_sink_0_0_0_0_0_0, '0']
- [blocks_moving_average_xx_1_0_0, '0', qtgui_number_sink_0_1_1_0_0, '0']
- [blocks_moving_average_xx_1_0_0_1, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_moving_average_xx_1_0_0_1, '0', qtgui_number_sink_0_1_1, '0']
- [blocks_moving_average_xx_2_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_moving_average_xx_2_0, '0', qtgui_number_sink_0_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0_1_1_0_0_0_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_vector_to_stream_0_1_1_0_0_0_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', blocks_vector_to_stream_0_1_1_0_0_0_0_0, '0']
- [blocks_skiphead_0_1_0_0_0_0_0, '0', blocks_keep_one_in_n_0_2_0_0_0_0_0, '0']
- [blocks_skiphead_0_1_0_0_0_0_0_0, '0', blocks_keep_one_in_n_0_2_0_0_0_0_0_0, '0']
- [blocks_skiphead_0_1_0_0_0_0_0_0_0, '0', blocks_keep_one_in_n_0_2_0_0_0_0_0_0_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', fft_vxx_0_1_0_0, '0']
- [blocks_stream_to_vector_1_0_0_0, '0', fft_vxx_0_1_0_0_0, '0']
- [blocks_stream_to_vector_1_0_0_0_0, '0', fft_vxx_0_1_0_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_throttle_0_0_0_0_0_0, '0', blocks_stream_to_vector_1_0_0_0, '0']
- [blocks_throttle_0_0_0_0_0_0_0, '0', blocks_stream_to_vector_1_0_0_0_0, '0']
- [blocks_vector_to_stream_0_1_1_0_0_0_0, '0', blocks_skiphead_0_1_0_0_0_0_0, '0']
- [blocks_vector_to_stream_0_1_1_0_0_0_0_0, '0', blocks_skiphead_0_1_0_0_0_0_0_0, '0']
- [blocks_vector_to_stream_0_1_1_0_0_0_0_0_0, '0', blocks_skiphead_0_1_0_0_0_0_0_0_0, '0']
- [fft_vxx_0_1_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0_0_0, '0']
- [fft_vxx_0_1_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0_0_0_0, '0']
- [fft_vxx_0_1_0_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0_0_0_0_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0_0_0_0_0_0_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '1', blocks_throttle_0_0_0_0_0_0, '0']
- [osmosdr_source_0, '2', blocks_throttle_0_0_0_0_0, '0']

metadata:
  file_format: 1
